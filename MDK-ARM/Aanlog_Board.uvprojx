# Keil uVision project Aanlog_Board.uvprojx, settings and files
target Aanlog_Board (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Aanlog_Board +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o Aanlog_Board\Aanlog_Board.bin Aanlog_Board\Aanlog_Board.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;               ../Middlewares/Third_Party/LwIP/src/include;               ../Middlewares/Third_Party/LwIP/system;               ../Drivers/STM32F4xx_HAL_Driver/Inc;               ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;               ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;               ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;               ../Middlewares/Third_Party/LwIP/src/include/lwip;               ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;               ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;               ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;               ../Middlewares/Third_Party/LwIP/src/include/netif;               ../Middlewares/Third_Party/LwIP/src/include/posix;               ../Middlewares/Third_Party/LwIP/src/include/posix/sys;               ../Middlewares/Third_Party/LwIP/system/arch;               ../Drivers/CMSIS/Include;               ..\Middlewares\Third_Party\Modbus\modbus;               ..\Middlewares\Third_Party\Modbus\port;               ..\Middlewares\Third_Party\Modbus\modbus\include;               ..\Middlewares\Third_Party\Modbus\modbus\functions;               ..\Middlewares\Third_Party\Modbus\modbus\tcp;               ..\Middlewares\Third_Party\Modbus\modbus\rtu;               ..\Middlewares\Third_Party\W25Q128;../Middlewares/Third_Party/LwIP/src/apps/httpd
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: lwip.c stm32f4xx_it.c stm32f4xx_hal_msp.c ethernetif.c main.c platform.c lcd1602.c flash_if.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6.c ip6_addr.c inet6.c icmp6.c ip6_frag.c mld6.c nd6.c dhcp6.c ethip6.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: pppapi.c vj.c fsm.c ecp.c ccp.c ipcp.c ppp.c chap-new.c ipv6cp.c pppcrypt.c magic.c multilink.c pppos.c demand.c pppol2tp.c eui64.c auth.c lcp.c pppoe.c chap_ms.c eap.c mppe.c chap-md5.c utils.c upap.c
    ../Middlewares/Third_Party/LwIP/src/core/: tcp.c mem.c tcp_out.c def.c ip.c sys.c udp.c memp.c stats.c netif.c dns.c pbuf.c timeouts.c raw.c inet_chksum.c tcp_in.c init.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_msg.c netbuf.c tcpip.c netdb.c netifapi.c api_lib.c sockets.c err.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4.c autoip.c icmp.c ip4_addr.c etharp.c dhcp.c igmp.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c slipif.c ethernet.c
    ../Middlewares/Third_Party/LwIP/src/apps/httpd/: fs.c httpd.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_dac.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_rtc.c
  group Middlewares/Modbus
    ../Middlewares/Third_Party/Modbus/modbus/: mb.c
    ../Middlewares/Third_Party/Modbus/modbus/tcp/: mbtcp.c
    ../Middlewares/Third_Party/Modbus/modbus/rtu/: mbcrc.c
    ../Middlewares/Third_Party/Modbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Middlewares/Third_Party/Modbus/port/: portevent.c portother.c porttcp.c
  group Middlewares/W25Q128
    ../Middlewares/Third_Party/W25Q128/: w25qxx.c
